# IAR project SnakeGame.ewp, settings and files
configuration SnakeGame (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H563xx
  ICCARM.PreInclude: ..\Application\main.h
  ICCARM.CCIncludePath2: ..\Application; ..\Hardware_Core\BSP\inc; ..\Hardware_Core\BSP\src; ..\Hardware_Core\Drivers\CMSIS; ..\Hardware_Core\Drivers\startup; ..\Hardware_Core\Drivers\STM32H5xx_HAL_Driver\Inc; ..\Hardware_Core\Drivers\STM32H5xx_HAL_Driver\Src; ..\Hardware_Core\SnakeGame
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SnakeGame.hex
  ILINK.IlinkOutputFile: SnakeGame.out
  ILINK.IlinkIcfFile: ..\Hardware_Core\Drivers\startup\stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../Application/: main.c
  group Hardware_Core/BSP
    ../Hardware_Core/BSP/src/: ButtonDriver.c BuzzerDriver.c LedDriver.c TimerDriver.c
  group Hardware_Core/Drivers/startup
    ../Hardware_Core/Drivers/startup/: partition_stm32h563xx.h partition_stm32h5xx.h startup_stm32h563xx.s stm32h563xx.h stm32h563xx_flash.icf stm32h5xx_hal_conf.h stm32h5xx_hal_msp.c stm32h5xx_it.c stm32h5xx_it.h system_stm32h5xx.c system_stm32h5xx.h
  group Hardware_Core/Drivers/STM32H5xx_HAL_Driver
    ../Hardware_Core/Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_cec.c stm32h5xx_hal_comp.c stm32h5xx_hal_cordic.c stm32h5xx_hal_cortex.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_dac.c stm32h5xx_hal_dac_ex.c stm32h5xx_hal_dcache.c stm32h5xx_hal_dcmi.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_dts.c stm32h5xx_hal_eth.c stm32h5xx_hal_eth_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_fmac.c stm32h5xx_hal_gpio.c stm32h5xx_hal_gtzc.c stm32h5xx_hal_hash.c stm32h5xx_hal_hcd.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i2s.c stm32h5xx_hal_i2s_ex.c stm32h5xx_hal_i3c.c stm32h5xx_hal_icache.c stm32h5xx_hal_irda.c stm32h5xx_hal_iwdg.c stm32h5xx_hal_lptim.c stm32h5xx_hal_mmc.c stm32h5xx_hal_mmc_ex.c stm32h5xx_hal_nand.c stm32h5xx_hal_nor.c stm32h5xx_hal_opamp.c stm32h5xx_hal_opamp_ex.c stm32h5xx_hal_otfdec.c stm32h5xx_hal_pcd.c stm32h5xx_hal_pcd_ex.c stm32h5xx_hal_pka.c stm32h5xx_hal_pssi.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_ramcfg.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rng.c stm32h5xx_hal_rng_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_sai.c stm32h5xx_hal_sai_ex.c stm32h5xx_hal_sd.c stm32h5xx_hal_sd_ex.c stm32h5xx_hal_sdram.c stm32h5xx_hal_smartcard.c stm32h5xx_hal_smartcard_ex.c stm32h5xx_hal_smbus.c stm32h5xx_hal_smbus_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_sram.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_usart.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_wwdg.c stm32h5xx_hal_xspi.c stm32h5xx_ll_adc.c stm32h5xx_ll_comp.c stm32h5xx_ll_cordic.c stm32h5xx_ll_crc.c stm32h5xx_ll_crs.c stm32h5xx_ll_dac.c stm32h5xx_ll_dlyb.c stm32h5xx_ll_dma.c stm32h5xx_ll_exti.c stm32h5xx_ll_fmac.c stm32h5xx_ll_fmc.c stm32h5xx_ll_gpio.c stm32h5xx_ll_i2c.c stm32h5xx_ll_i3c.c stm32h5xx_ll_icache.c stm32h5xx_ll_lptim.c stm32h5xx_ll_lpuart.c stm32h5xx_ll_opamp.c stm32h5xx_ll_pka.c stm32h5xx_ll_pwr.c stm32h5xx_ll_rcc.c stm32h5xx_ll_rng.c stm32h5xx_ll_rtc.c stm32h5xx_ll_sdmmc.c stm32h5xx_ll_spi.c stm32h5xx_ll_tim.c stm32h5xx_ll_ucpd.c stm32h5xx_ll_usart.c stm32h5xx_ll_usb.c stm32h5xx_ll_utils.c
  group Hardware_Core/SnakeGame
    ../Hardware_Core/SnakeGame/: SnakeGame.c
